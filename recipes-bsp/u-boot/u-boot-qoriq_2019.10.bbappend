SRC_URI_remove = "git://source.codeaurora.org/external/qoriq/qoriq-components/u-boot;nobranch=1"
SRC_URI += "git://git@github-readonly-shared/Scalys/trustsom-uboot.git;nobranch=1;protocol=ssh"
SRCREV = "eb697060939d85b4ba2104852119d8e416892719"
