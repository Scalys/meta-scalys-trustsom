SRC_URI_remove = "git://source.codeaurora.org/external/qoriq/qoriq-components/cst;nobranch=1"
SRC_URI += "git://git@github-readonly-shared/Scalys/trustsom-cst.git;branch=trustsom-LSDK-20.04;protocol=ssh"
SRCREV = "9aafbdf2441858ceca2779279b6876c6bdc2d3ed"

