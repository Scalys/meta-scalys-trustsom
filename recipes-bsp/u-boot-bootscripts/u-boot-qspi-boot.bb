DESCRIPTION = "U-boot script for booting linux kernel + root from UBIFS"

include u-boot-bootscript.inc

BOOT_SCRIPT = "boot-qspi.cmd"
BOOT_SCRIPT_DESC = "Boot linux from UBIFS"
