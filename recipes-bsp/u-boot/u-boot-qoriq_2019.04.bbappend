SRC_URI = "git://github.com/Scalys/u-boot-qoriq.git;protocol=git;branch=scalys-2019.04"
SRCREV = "14c63beee9aa5b9d212b51db7986e5d585ca7362"
